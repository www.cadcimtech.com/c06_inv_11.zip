# Autodesk Inventor part: fig-6-24
## iProperties
Created: 2005-04
Part Number: fig-6-24
Document SubType Name: Modeling
Designer: CADCIM
Author: CADCIM
## Feature names
1. Extrusion1
2. Extrusion2
